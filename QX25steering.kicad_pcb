# Repository takahashirenya/QX25steering

## KiCad design QX25steering.kicad_pcb

Parts:
C24, C25: 16V1800μF; CP_Radial_D10.0mm_P5.00mm
C28, C29, C30, C31: 100n; C_0805_2012Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J4: R_HAT_GEAR; JST_XH_B6B-XH-AM_1x06_P2.50mm_Vertical
J5: L_HAT_GEAR; JST_XH_B6B-XH-AM_1x06_P2.50mm_Vertical
J6: PWM_SPARE1; JST_VH_B3P-VH-B_1x03_P3.96mm_Vertical
J7: PWM_SPARE3; JST_VH_B3P-VH-B_1x03_P3.96mm_Vertical
J8: PWM_SPARE2; JST_VH_B3P-VH-B_1x03_P3.96mm_Vertical
J9: PWM_SPARE4; JST_VH_B3P-VH-B_1x03_P3.96mm_Vertical
J10: ELE; JST_VH_B3P-VH-B_1x03_P3.96mm_Vertical
J11: LAD; JST_VH_B3P-VH-B_1x03_P3.96mm_Vertical
J12: PIROT; JST_XH_B5B-XH-AM_1x05_P2.50mm_Vertical
J13: logger; JST_XH_B3B-XH-AM_1x03_P2.50mm_Vertical
J14: PIROT_SPARE; JST_XH_B5B-XH-AM_1x05_P2.50mm_Vertical
LED1, LED2: AP1608SURCK; Manufacturer_Part_Number AP1608SURCK; Mouser Part Number 604-AP1608SURCK
R18, R19: 10k; R_0805_2012Metric
R26, R27: 100; R_0805_2012Metric

Connections:
+3V3: J12.1, J14.1; also elsewhere on the board
+8V: J4.2, J4.5, J5.2, J5.5, J6.2, J7.2, J8.2, J9.2; also elsewhere on the board
/ELE: R26.1; also elsewhere on the board
/ELE_ANP/ELE_LOAD: C25.2, C28.2, C29.2, J10.2; also elsewhere on the board
/LAD: R27.2; also elsewhere on the board
/LAD_ANP/LAD_LOAD: C24.2, C30.2, C31.2, J11.2; also elsewhere on the board
/LED1: LED1.1 (A); also elsewhere on the board
/LED2: LED2.1 (A); also elsewhere on the board
/L_GEAR: J5.1; also elsewhere on the board
/L_HAT: J5.4; also elsewhere on the board
/PWM_SPARE1: J6.1; also elsewhere on the board
/PWM_SPARE2: J8.1; also elsewhere on the board
/PWM_SPARE3: J7.1; also elsewhere on the board
/PWM_SPARE4: J9.1; also elsewhere on the board
/P_ELE: J12.2; also elsewhere on the board
/P_ELE_SPARE: J14.2; also elsewhere on the board
/P_LAD: J12.3; also elsewhere on the board
/P_LAD_SPARE: J14.3; also elsewhere on the board
/P_SW: J12.4; also elsewhere on the board
/P_SW_SPARE: J14.4; also elsewhere on the board
/R_GEAR: J4.1; also elsewhere on the board
/R_HAT: J4.4; also elsewhere on the board
/uart_rx: J13.2; also elsewhere on the board
/uart_tx: J13.3; also elsewhere on the board
GND: C24.1, C25.1, C28.1, C29.1, C30.1, C31.1, J4.3, J4.6, J5.3, J5.6, J6.3, J7.3, J8.3, J9.3, J10.1, J11.1, J12.5, J13.1, J14.5, R18.2, R19.2; also elsewhere on the board
unnamed: J10.3, R26.2
unnamed: J11.3, R27.1
unnamed: LED1.2 (K), R18.1
unnamed: LED2.2 (K), R19.1

Parts:
C23: 1u; C_0805_2012Metric
LS2: PKB24SPCH-3601-B0; PKB24SPCH3601B0; Manufacturer_Part_Number PKB24SPCH-3601-B0; Mouser Part Number 81-PKB24SPC-3601
Q1: 2SC3325-Y,LF; 2SC3325YLF; Manufacturer_Part_Number 2SC3325-Y,LF; Mouser Part Number 757-2SC3325-YLF
R10: 220; R_0805_2012Metric
R11: 33k; R_0805_2012Metric
SW3: SW_SPDT; FanPinHeader_1x03_P2.54mm_Vertical

Connections:
+8V: R10.1; also elsewhere on the board
/!buzzer: R11.2; also elsewhere on the board
GND: C23.2, Q1.2 (E), SW3.3 (C); also elsewhere on the board
unnamed: C23.1, LS2.2 (+), R10.2
unnamed: LS2.1 (-), SW3.1 (A)
unnamed: Q1.1 (B), R11.1
unnamed: Q1.3 (C), SW3.2 (B)

Parts:
J3: DM3AT-SF-PEJM5_40_; DM3ATSFPEJM540; Manufacturer_Part_Number DM3AT-SF-PEJM5(40); Mouser Part Number 798-DM3AT-SF-PEJM540

Connections:
+3V3: J3.4 (VDD); also elsewhere on the board
/CS_SD: J3.2 (CD/DAT3); also elsewhere on the board
/MISO_SD: J3.7 (DAT0); also elsewhere on the board
/MOSI_SD: J3.3 (CMD); also elsewhere on the board
/SCK_SD: J3.5 (CLK); also elsewhere on the board
GND: J3.6 (VSS); also elsewhere on the board

Parts:
C1, C2, C3, C18: 4.7u; C_0402_1005Metric
C4, C5, C6, C7, C32: 10u; C_0805_2012Metric
C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C19, C20: 100n; C_0402_1005Metric
C21, C22: 15p; C_0402_1005Metric
D1, D2: D; D_SMA
D7: D; D_P600_R-6_P7.62mm_Vertical_AnodeUp
IC1: NCP1117ST50T3G; SOT230P700X180-4N; Manufacturer_Part_Number NCP1117ST50T3G; Mouser Part Number 863-NCP1117ST50T3G
J1: USB_B_Micro; 101181940001LF
J2: Conn_01x02; JST_VH_B2P-VH-B_1x02_P3.96mm_Vertical
J15: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
L1: 3.3u; L_pol_2016
R1, R2: 27; C_0402_1005Metric
R3: 33; C_0402_1005Metric
R4: 10k; C_0402_1005Metric
R5: 0; C_0402_1005Metric
R6, R7, R9: 1k; C_0402_1005Metric
SW1, SW2: SW_Push; SW_Push_1P1T_NO_Vertical_Wuerth_434133025816
U1: RP2350_80QFN; RP2350-QFN-80-1EP_10x10_P0.4mm_EP3.4x3.4mm_ThermalVias
U2: NCP1117-3.3_SOT223; SOT-223-3_TabPin2
U3: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
Y1: ABM8-272-T3; ABM8272T3; Manufacturer_Part_Number ABM8-272-T3; Mouser Part Number 815-ABM8-272-T3

Connections:
+1V1: C2.1, C17.1, C18.1, C19.1, L1.1, U1.10 (DVDD), U1.32 (DVDD), U1.51 (DVDD), U1.65 (VREG_FB)
+3V3: C3.1, C5.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C20.2, C32.1, J15.5, R3.2, R4.2, U1.5 (IOVDD), U1.15 (IOVDD), U1.24 (IOVDD), U1.29 (IOVDD), U1.41 (IOVDD), U1.50 (IOVDD), U1.59 (ADC_AVDD), U1.60 (IOVDD), U1.64 (VREG_VIN), U1.68 (USB_OTP_VDD), U1.69 (QSPI_IOVDD), U1.76 (IOVDD), U2.2 (VO), U3.8 (VCC); also elsewhere on the board
+5V: C7.1, D2.2 (A), IC1.2 (OUTPUT_1), IC1.4 (OUTPUT_2)
+8V: C6.1, D7.1 (K), IC1.3 (INPUT); also elsewhere on the board
/!buzzer: U1.46 (GPIO37); also elsewhere on the board
/CS_SD: U1.21 (GPIO21); also elsewhere on the board
/ELE: U1.36 (GPIO28); also elsewhere on the board
/ELE_PIO: U1.52 (GPIO41_ADC1); also elsewhere on the board
/LAD: U1.22 (GPIO22); also elsewhere on the board
/LAD_PIO: U1.49 (GPIO40_ADC0); also elsewhere on the board
/LED1: U1.3 (GPIO6); also elsewhere on the board
/LED2: U1.2 (GPIO5); also elsewhere on the board
/L_GEAR: U1.80 (GPIO3); also elsewhere on the board
/L_HAT: U1.1 (GPIO4); also elsewhere on the board
/MISO_SD: U1.20 (GPIO20); also elsewhere on the board
/MOSI_SD: U1.19 (GPIO19); also elsewhere on the board
/PWM_SPARE1: U1.25 (GPIO24); also elsewhere on the board
/PWM_SPARE2: U1.27 (GPIO26); also elsewhere on the board
/PWM_SPARE3: U1.38 (GPIO30); also elsewhere on the board
/PWM_SPARE4: U1.40 (GPIO32); also elsewhere on the board
/P_ELE: U1.58 (GPIO47_ADC7); also elsewhere on the board
/P_ELE_SPARE: U1.56 (GPIO45_ADC5); also elsewhere on the board
/P_LAD: U1.57 (GPIO46_ADC6); also elsewhere on the board
/P_LAD_SPARE: U1.55 (GPIO44_ADC4); also elsewhere on the board
/P_SW: U1.48 (GPIO39); also elsewhere on the board
/P_SW_SPARE: U1.47 (GPIO38); also elsewhere on the board
/RP2350B/GPIO0: R4.1, R5.1, U1.77 (GPIO0), U3.1 (~CS)
/RP2350B/GPIO14: J15.1, U1.13 (GPIO14)
/RP2350B/GPIO15: J15.2, U1.14 (GPIO15)
/RP2350B/GPIO16: J15.3, U1.16 (GPIO16)
/RP2350B/GPIO17: J15.4, U1.17 (GPIO17)
/RP2350B/QSPI_SCLK: U1.71 (QSPI_SCLK), U3.6 (CLK)
/RP2350B/QSPI_SD0: U1.72 (QSPI_SD0), U3.5 (DI(IO0))
/RP2350B/QSPI_SD1: U1.74 (QSPI_SD1), U3.2 (DO(IO1))
/RP2350B/QSPI_SD2: U1.73 (QSPI_SD2), U3.3 (IO2)
/RP2350B/QSPI_SD3: U1.70 (QSPI_SD3), U3.7 (IO3)
/RP2350B/QSPI_SS: R5.2, R6.1, U1.75 (QSPI_SS)
/RP2350B/USB_D+: J1.3 (D+), R1.1
/RP2350B/USB_D-: J1.2 (D-), R2.1
/RP2350B/XIN: C21.1, U1.30 (XIN), Y1.1 (CRYSTAL_1)
/RP2350B/XOUT: R7.1, U1.31 (XOUT)
/RP2350B/~USB_BOOT: R6.2, SW1.2
/R_GEAR: U1.45 (GPIO36); also elsewhere on the board
/R_HAT: U1.43 (GPIO34); also elsewhere on the board
/SCK_SD: U1.18 (GPIO18); also elsewhere on the board
/uart_rx: U1.7 (GPIO9); also elsewhere on the board
/uart_tx: U1.6 (GPIO8); also elsewhere on the board
GND: C1.2, C2.2, C3.2, C4.1, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.1, C21.2, C22.2, C32.2, IC1.1 (ADJUST/GROUND), J1.5 (GND), J1.6 (Shield), J2.1, J15.6, R9.2, SW1.1, U1.62 (VREG_PGND), U1.81 (GND), U2.1 (GND), U3.4 (GND), Y1.2 (GND_1), Y1.4 (GND_2); also elsewhere on the board
unnamed: D1.2 (A), J1.1 (VBUS)
unnamed: D7.2 (A), J2.2
unnamed: R9.1, SW2.1
unnamed: SW2.2, U1.35 (RUN)
unnamed: R2.2, U1.66 (USB_DM)
unnamed: R1.2, U1.67 (USB_DP)
unnamed: C1.1, R3.1, U1.61 (VREG_AVDD)
unnamed: L1.2, U1.63 (VREG_LX)
unnamed: C22.1, R7.2, Y1.3 (CRYSTAL_2)
VBUS: C4.2, D1.1 (K), D2.1 (K), U2.3 (VI)

Notes on the sheet:
POWER
Primary Flash

Parts:
C26: 0.1μ; C_0805_2012Metric
D3, D4: D_Zener 3V; D_SOD-123
D9: PESD3V3L1BA; SOD2512X110N; Manufacturer_Part_Number PESD3V3L1BA; Mouser Part Number N/A
R12: 0.01; R_1206_3216Metric
R13: 51; R_0805_2012Metric
R14: 10k; R_0805_2012Metric
R20, R21: DNP; LED_0805_2012Metric
R22: 27; R_0805_2012Metric
U4: LT6106; SOT-23-5

Connections:
+8V: R12.1, R20.2, R21.2, U4.5 (V+); also elsewhere on the board
/ELE_ANP/-IN: R13.1, R22.1, U4.3 (-)
/ELE_ANP/ELE_LOAD: R12.2, U4.4 (+); also elsewhere on the board
/ELE_PIO: D3.2 (A), D9.1; also elsewhere on the board
GND: C26.1, D4.2 (A), D9.2, R14.2, U4.2 (V-); also elsewhere on the board
unnamed: C26.2, D3.1 (K), D4.1 (K), R14.1, U4.1
unnamed: R13.2, R20.1
unnamed: R21.1, R22.2

Notes on the sheet:
Rsense
Rinははんだ付けで切り替え可能にした。
Vout=Isense×Rsense×(Rout/Rin) Gain=Rout/Rin Vsense=Isense×Rsense Vout=Vsemse×Gain データシート参照
Rout

Parts:
C27: 0.1μ; C_0805_2012Metric
D5, D6: D_Zener 3V; D_SOD-123
D10: PESD3V3L1BA; SOD2512X110N; Manufacturer_Part_Number PESD3V3L1BA; Mouser Part Number N/A
R15: 0.01; R_1206_3216Metric
R16, R17: DNP; R_0805_2012Metric
R23: 51; R_0805_2012Metric
R24: 27; R_0805_2012Metric
R25: 10k; R_0805_2012Metric
U5: LT6106; SOT-23-5

Connections:
+8V: R15.1, R16.2, R17.2, U5.5 (V+); also elsewhere on the board
/LAD_ANP/-IN: R23.1, R24.1, U5.3 (-)
/LAD_ANP/LAD_LOAD: R15.2, U5.4 (+); also elsewhere on the board
/LAD_PIO: D6.2 (A), D10.1; also elsewhere on the board
GND: C27.1, D5.2 (A), D10.2, R25.2, U5.2 (V-); also elsewhere on the board
unnamed: C27.2, D5.1 (K), D6.1 (K), R25.1, U5.1
unnamed: R16.1, R23.2
unnamed: R17.1, R24.2

Notes on the sheet:
Rout
Vout=Isense×Rsense×(Rout/Rin) Gain=Rout/Rin Vsense=Isense×Rsense Vout=Vsemse×Gain データシート参照

Board: 2 copper layers, 100.0 x 100.0 mm, 101 parts (0 on the bottom side), 76 nets.

## Commit log (part)

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2025-12-04 25/12/04
